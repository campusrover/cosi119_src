Commit message: checkpoint

File: samples/urdf/platform3.urdf (robot description, URDF)
Before this commit: robot platform, 7 links, 6 joints
Joints:
- joint base_to_left_wheel: origin xyz=0.0 0.15 0.03 rpy=1.57 0 0 -> xyz=0.0 0.15 0.03 rpy=0 0 0
